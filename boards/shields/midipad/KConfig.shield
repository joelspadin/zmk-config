## boards/shields/midipad/KConfig.shield
```kconfig
# Copyright (c) 2020 Joel Spadin
# SPDX-License-Identifier: MIT

config SHIELD_MIDIPAD
	def_bool $(shields_list_contains,midipad)
```
